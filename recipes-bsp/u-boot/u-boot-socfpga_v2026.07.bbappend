FILESEXTRAPATHS:prepend := "${THISDIR}/config:"

SRC_URI:append:de10-standard = " file://de10-standard-boot.cfg"
